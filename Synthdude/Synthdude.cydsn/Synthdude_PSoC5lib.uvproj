# Keil uVision project Synthdude_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x0-0x3FFFF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: Synthdude_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h VDAC8_1.c VDAC8_1.h VDAC8_1_PM.c P0_2_aliases.h P0_2.c P0_2.h isr_1.c isr_1.h Timer_1.c Timer_1.h Timer_1_PM.c UART_1.c UART_1.h UART_1_PM.c UART_1_INT.c UART_1_BOOT.c UART_1_IntClock.c UART_1_IntClock.h cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h Timer_2.c Timer_2.h Timer_2_PM.c timer_clock_1.c timer_clock_1.h isr_2.c isr_2.h
target Release (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: as above
  output: Synthdude_PSoC5lib (library)
